## sdkconfig.defaults
```kconfig
CONFIG_BT_ENABLED=y
CONFIG_NIMBLE_ENABLED=y
CONFIG_BT_CONTROLLER_ENABLED=y
CONFIG_BTDM_CONTROLLER_MODE_BLE_ONLY=y
```
